# Keil uVision project Project.uvprojx, settings and files
target Project New (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project2023 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F401xx,USE_STDPERIPH_DRIVER
  c include: .\User\Inc;.\Libraries\CMSIS\Include;.\Libraries\CMSIS\Device\ST\STM32F4xx\Include;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\Hardware\Inc;.\Software\Inc;.\System\Inc;.\Cfg;.\Ports;.\Source;.\Trace\Systemview_con;.\Trace\Systemview_src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group CMSIS
    ./Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ./Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f401xx.s
  group USER
    ./User/Src/: stm32f4xx_it.c main .c
  group STM32F4xx_StdPeriph_Driver
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Source
    ./Source/: os.h os_core.c os_dbg_r.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c os_trace.h ucos_ii.h
  group Ports
    ./Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group Cfg
    ./Cfg/: app_cfg.h app_hooks.c os_cfg.h
  group System
    ./System/Src/: Delay.c
    ./System/Inc/: Delay.h
  group Software
    ./Software/Inc/: PWM.h USART.h Acc.h Anto.h Madgwick.h Quaternion.h PID.h
    ./Software/Src/: PWM.c USART.c Acc.c Anto.c Madgwick.c Quaternion.c PID.c
  group Hardware
    ./Hardware/Inc/: Receiver.h Motor.h Serial.h GY86.h HMC5883L.h HMC5883LAdress.h MPU.h MPU6050Adress.h MyI2C.h OLED.h OLED_Font.h
    ./Hardware/Src/: Motor.c Receiver.c Serial.c GY86.c HMC5883L.c MPU.c MyI2C.c OLED.c
  group sys_conf
    ./Trace/Systemview_con/: Global.h os_cfg_trace.h SEGGER_RTT_Conf.h SEGGER_SYSVIEW_Conf.h SEGGER_SYSVIEW_Config_uCOSII.c
  group sys_src
    ./Trace/Systemview_src/: os_trace_events.h SEGGER.h SEGGER_RTT.c SEGGER_RTT.h SEGGER_SYSVIEW.c SEGGER_SYSVIEW.h SEGGER_SYSVIEW_ConfDefaults.h SEGGER_SYSVIEW_Int.h SEGGER_SYSVIEW_uCOSII.c
